# Keil uVision project rx_head_cond.uvprojx, settings and files
target MB9BFxx4_Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MB9BF164K Cypress
  pack: Keil.FM4_DFP.1.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x2003E000,0x4000) IRAM2(0x1FFFC000,0x4000) IROM2(0x200C0000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rx_head_cond
  BeforeMake: ..\VersionUpdate.exe .\source\version.c
  AfterMake: fromelf.exe --bin --output=_out\Debug-cond\rx_head_cond.bin _out\Debug-cond\rx_head_cond.axf
  AfterMake: C:\Windows\System32\cmd.exe /C copy /B _out\Debug-cond\rx_head_cond.bin+.\source\version.txt ..\bin\head\rx_head_cond
  c flags: Optim=1 uC99=1 wLevel=2
  c define: COND, DEBUG, AVERAGE, PID
  c include: .\common;.\source;.\library\driver;.\library\highlevel;..\rx_common_lib;..\rx_ink_lib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x2003e000 size 0x4000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  group common
    ./common/: system_mb9abxxx.c
  group source_files
    ./source/: main.c iomux.c i2c.c debug_printf.c uart.c version.c work_flash_operation.c watchdog.c temp_ctrl.c pres.c pump_ctrl.c eeprom.c i2c_bitbang.c pumptime.c average.c average.h pid.c
    ./common/: startup_mb9bf16xl.s
  group driver
    ./library/driver/: pdl.c
    ./library/driver/gpio/: gpio.h
    ./library/driver/clk/: clk.c
    ./library/driver/flash/: work_flash.c
  group header files
    ./source/: pump_ctrl.h pres.h temp_ctrl.h work_flash_operation.h watchdog.h uart.h iomux.h pdl_user.h i2c.h eeprom.h i2c_bitbang.h main.h debug_printf.h pumptime.h pid.h
  group rx_ink_lib
    ../rx_ink_lib/: comm.c fifo.c comm.h fifo.h cond_def_head.h rx_ink_common.h rx_ink_common.c
target MB9BFxx4_Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MB9BF164K Cypress
  pack: Keil.FM4_DFP.1.5.0
  cpu: as above
  output: rx_head_cond +hex
  BeforeMake: ..\VersionUpdate.exe .\source\version.c
  AfterMake: fromelf.exe --bin --output=_out\Release-cond\rx_head_cond.bin _out\Release-cond\rx_head_cond.axf
  AfterMake: C:\Windows\System32\cmd.exe /C copy /B _out\Release-cond\rx_head_cond.bin+.\source\version.txt ..\bin\head\rx_head_cond
  c flags: Optim=1 uC99=1
  c define: COND, AVERAGE, PID
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x2003e000 size 0x4000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
target debug_release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MB9BF164K Cypress
  pack: Keil.FM4_DFP.1.5.0
  cpu: as above
  output: blinky_bootloader
  BeforeMake: ..\VersionUpdate.exe .\source\version.c
  AfterMake: C:\Keil_v5_spansion\ARM\ARMCC\bin\fromelf.exe --bin --output=_out\Release-cond\rx_head_cond.bin _out\Release-cond\rx_head_cond.axf
  AfterMake: .\update_hex_file.bat
  c flags: Optim=1 uC99=1
  c define: COND
  c include: .\common;.\source;.\library\driver;.\library\highlevel
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x2003e000 size 0x4000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
software components: CMSIS:CORE 4.3.0
