# Keil uVision project rx_balance_ctrl.uvprojx, settings and files
target MB9BFxx4_Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MB9BF164K Cypress
  pack: Keil.FM4_DFP.1.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x2003E000,0x4000) IRAM2(0x1FFFC000,0x4000) IROM2(0x200C0000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rx_balance_ctrl
  BeforeMake: ..\VersionUpdate.exe .\source\version.c
  c flags: Optim=1 uC99=1 wLevel=2
  c define: VENT_BALANCE COND
  c include: .\common;.\source;.\library\driver;.\library\highlevel;..\rx_common_lib;..\rx_ink_lib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x2003e000 size 0x4000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  group common
    ./common/: system_mb9abxxx.c
  group source_files
    ./source/: main.c iomux.c i2c.c debug_printf.c version.c watchdog.c crc_calc.c uart.c balance.c sensor.c
    ./common/: startup_mb9bf16xl.s
  group driver
    ./library/driver/clk/: clk.c
    ./library/driver/: pdl.c
    ./library/driver/gpio/: gpio.h
  group header files
    ./source/: version.h iomux.h watchdog.h pdl_user.h i2c.h crc_calc.h uart.h main.h balance.h sensor.h
  group rx_ink_lib
    ../rx_ink_lib/: comm.c fifo.c rx_ink_common.c comm.h fifo.h nios_def_head.h rx_ink_common.h balance_def.h
target MB9BFxx4_Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MB9BF164K Cypress
  pack: Keil.FM4_DFP.1.5.0
  cpu: as above
  output: rx_head_cond
  BeforeMake: ..\VersionUpdate.exe .\source\version.c
  c flags: uC99=1
  c define: VENT_BALANCE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x2003e000 size 0x4000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
software components: CMSIS:CORE 4.3.0
